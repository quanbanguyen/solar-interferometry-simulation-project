options:
  parameters:
    author: quanba
    generate_options: qt_gui
    id: hehe
    output_language: python
    title: 'FM test '
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 102e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.92e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '8'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: sdrplay3_rspdx_0
  id: sdrplay3_rspdx
  parameters:
    AGC: 'True'
    agc_set_point: '-30'
    antenna: Antenna B
    bandwidth: 200e3
    biasT: 'False'
    center_freq: freq
    dab_notch_filter: 'False'
    dc_offset_mode: 'False'
    debug_mode: 'False'
    freq_corr: '0'
    hdr_mode: 'False'
    if_gRdB: '40'
    iq_balance_mode: 'False'
    output_type: fc32
    rf_gRdB: '0'
    rf_notch_filter: 'False'
    rsp_selector: '""'
    sample_rate: samp_rate
    sample_sequence_gaps_check: 'False'
    show_gain_changes: 'False'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_1, '0', analog_wfm_rcv_0, '0']
- [sdrplay3_rspdx_0, '0', low_pass_filter_1, '0']
- [sdrplay3_rspdx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
